# IAR project Backup (6) of vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: C:\Users\ＶＭｏｏｒ\Desktop\FTM_PWM_示波器 - 副本\Prj\IAR\config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/Inc/: ANGEL.h calculate_PWM.h codetab.h Filter_2.h IMU_IIC.h L3G4200.h MK60_conf.h MK60_it.h MMA8451.h OLED_I2C.h PORT_cfg.h
    ../../App/: calculate_PWM.c Filter_2.c IMU_IIC.c L3G4200.c main.c MK60_conf.c MK60_it.c MMA8451.c OLED_I2C.c Scopeinterface.c Scopeinterface.h
    ../../Chip/inc/kinetis/: MK60DZ10.h
  group Board
    ../../Board/src/: VCAN_key.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
